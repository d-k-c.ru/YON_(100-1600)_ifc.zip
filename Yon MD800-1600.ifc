Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Yon MD800-1600.ifc
Time: 2021-07-13T11:05:33+03:00
Written by: IFC Interface 4.4 by CT CoreTechnologie
Made in: 3D_Evolution4.4 by CT CoreTechnologie

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuilding, Default Building
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm
